# Keil uVision project hikari.uvproj, settings and files
target STC16F40K (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: smartCar +hex
  link misc: REMOVEUNUSED
  group Lib
    ../Lib/seekfree_libraries/: zf_adc.c zf_delay.c zf_exti.c zf_gpio.c zf_iic.c zf_mdu16.c zf_nvic.c zf_pwm.c zf_spi.c zf_tim.c zf_uart.c
  group Periph
    ../Lib/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_AT24C02.c SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_FONT.c SEEKFREE_IIC.c SEEKFREE_WIRELESS.c
  group Core
    ../Lib/libraries/: board.c common.c SEEKFREE_PRINTF.c STC_DFP.LIB STC16_FPMU_V10.LIB STC16_MDU32_V10.LIB
  group Code
    ../Code/: isr.c main.c
  group User
    ../User/: buzz.c encoder.c indNavi.c key.c misc.c motor.c pid.c servo.c ui.c
  group AltPeriph
    ../Periph/: DisplayFont.c TFT18.c
  group LibV2
    ../LibV2/STC_Periph/: al_stc16x_adc.c al_stc16x_gpio.c al_stc16x_tim.c
  group CoreV2
    ../LibV2/STC_Core/: STC16_MDU32_V10.LIB stc16f.h al_stdint.h STC_DFP.LIB STC16_FPMU_V10.LIB
