# Keil uVision project hikari.uvproj, settings and files
target STC16F40K (MCS-251)
  device: STC16F40K128 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x17FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: smartCar +hex
  link misc: REMOVEUNUSED
  group Lib
    ./Lib/seekfree_libraries/: zf_adc.c zf_delay.c zf_exti.c zf_gpio.c zf_iic.c zf_mdu16.c zf_nvic.c zf_pwm.c zf_spi.c zf_tim.c zf_uart.c
  group Periph
    ./Lib/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_AT24C02.c SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_FONT.c SEEKFREE_IIC.c SEEKFREE_WIRELESS.c
  group Core
    ./Lib/libraries/: board.c common.c SEEKFREE_PRINTF.c STC_DFP.LIB STC16_FPMU_V10.LIB STC16_MDU32_V10.LIB
  group Code
    ./Code/: isr.c main.c
  group User
    ./User/: buzz.c key.c misc.c encoder.c motor.c servo.c indNavi.c pid.c
